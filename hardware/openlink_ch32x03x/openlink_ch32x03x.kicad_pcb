# Repository OpenHME/HME-OpenLink

## KiCad design hardware/openlink_ch32x03x/openlink_ch32x03x.kicad_pcb

Parts:
C1, C3, C5: 1uF; C_0402_1005Metric
C2, C4, C6, C7: 0.1uF; C_0402_1005Metric
D1: YELLOW; LED_0603_1608Metric
J1: USB_A; USB-AM-180
J2: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J3: Conn_02x05_Odd_Even; IDC-Header_2x05_P2.54mm_Vertical
JP1, JP2, JP3, JP4, JP5, JP6, JP7: Jumper_2_Small_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP8: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm_NumberLabels
R1, R5: 470; R_0402_1005Metric
R2, R3, R4, R6, R7: 4.7k; R_0402_1005Metric
TP1, TP2, TP3: TestPoint; TestPoint_Pad_D1.0mm
U1: CH32X033F8P6; TSSOP-20_4.4x6.5mm_P0.65mm
U2: CH32X035F8U6; QFN-20-1EP_3x3mm_P0.4mm_EP1.65x1.65mm
U3: XC6206-3.3; SOT-23
U4: ZB25VQ128; SOIC-8_P1.27mm_Common
U5, U6: 74AVC4T774; TSSOP-16_4.4x5mm_P0.65mm

Connections:
/ADC: R6.2, R7.2, U1.13 (PC3), U2.10 (PB0)
/DCK: TP2.1, U1.18 (PC19), U2.16 (PC19)
/DIO: TP1.1, U1.8 (PC18), U2.14 (PC18)
/F8P6_PA9: U1.10 (PA9), U2.19 (PC14), U4.1 (~CS)
/F8P6_PA10: R1.2, U1.12 (PA10), U2.12 (PB3), U6.3 (A1)
/F8P6_PA11: JP5.1 (A), U1.11 (PA11), U2.13 (PB11), U6.4 (A2)
/F8P6_PB7: D1.1 (K), U1.4 (PB7), U2.20 (PC15)
/F_CLK: U1.14 (PA0), U2.2 (PA0), U4.6 (CLK)
/F_MISO: U1.15 (PA1), U2.3 (PA1), U4.2 (DO(IO1))
/F_MOSI: U1.3 (PB1), U2.11 (PB1), U4.5 (DI(IO0))
/GND|Busy: J3.2, R1.1, R5.1
/MISO: JP2.1 (A), U1.1 (PA6), U2.8 (PA6), U5.4 (A2)
/MOSI: JP1.1 (A), U1.2 (PA7), U2.9 (PA7), U5.3 (A1)
/NSS: JP3.1 (A), U1.19 (PA4), U2.6 (PA4), U5.5 (A3)
/RXD|Start: J3.7, JP6.2 (B), U6.12 (B3)
/SCK: JP4.1 (A), U1.20 (PA5), U2.7 (PA5), U5.6 (A4)
/SRST|Fail: J3.8, JP5.2 (B), U6.13 (B2)
/TCK: J3.1, JP4.2 (B), U5.11 (B4)
/TDI: J3.9, JP1.2 (B), U5.14 (B1)
/TDO: J3.3, JP2.2 (B), U5.13 (B2)
/TMS: J3.5, JP3.2 (B), U5.12 (B3)
/TXD|Success: J3.6, JP7.2 (B), U6.11 (B4)
/USART2_RX: JP6.1 (A), U1.17 (PA3), U2.5 (PA3), U6.5 (A3)
/USART2_TX: JP7.1 (A), U1.16 (PA2), U2.4 (PA2), U6.6 (A4)
/USB5V: C1.2, J1.1 (VBUS), U3.3 (VIN)
/USB_D+: J1.3 (D+), U1.6 (PC17/UDP), U2.18 (PC17/P)
/USB_D-: J1.2 (D-), U1.5 (PC16/UDM), U2.17 (PC16/N)
/VCC3V3: C4.2, C5.2, R2.1, R3.1, U4.8 (VCC)
/VDD: C2.2, C3.2, C6.2, J2.1, JP8.1 (A), R4.1, U1.9 (VDD), U2.1 (VDD), U3.2 (VOUT), U5.1 (DIR1), U5.7 (DIR3), U5.8 (DIR4), U5.16 (VCCA), U6.1 (DIR1), U6.2 (DIR2), U6.8 (DIR4), U6.16 (VCCA)
/VRef_JTAG: C7.2, J2.3, J3.4, JP8.3 (B), R6.1, U5.15 (VCCB)
/VRef_MISC: J2.2, JP8.2 (C), U6.15 (VCCB)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, J1.4 (GND), J1.5 (Shield), J3.10, R7.1, TP3.1, U1.7 (GND), U2.21 (GND), U3.1 (VSS), U4.4 (GND), U4.9 (EP), U5.2 (DIR2), U5.9 (nOE), U5.10 (GND), U6.7 (DIR3), U6.9 (nOE), U6.10 (GND)
unnamed: D1.2 (A), R4.2
unnamed: R2.2, U4.3 (IO2)
unnamed: R3.2, U4.7 (IO3)
unnamed: R5.2, U6.14 (B1)

Notes on the sheet:
电平转换： 单3.3V选左，其他情况选右 注1：470R可NC，仅用于离线 烧录场景输出Busy信号 注2：JP1-JP7可简化为直连
离线烧录，按需选贴
主控封装： 二选一

Board: 2 copper layers, 35.6 x 21.6 mm, 35 parts (13 on the bottom side), 36 nets.
